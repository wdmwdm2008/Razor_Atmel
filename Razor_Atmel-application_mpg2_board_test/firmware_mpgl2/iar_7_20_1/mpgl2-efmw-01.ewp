# IAR project mpgl2-efmw-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: MPGL2; MPG2
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\libraries\captouch; ..\..\firmware_mpg_common; ..\..\firmware_mpg_common\application; ..\..\firmware_mpg_common\cmsis; ..\..\firmware_mpg_common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mpgl2-efmw-01.hex
  ILINK.IlinkOutputFile: mpgl2.out
  ILINK.IlinkIcfFile: ..\..\firmware_mpg_common\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Includes
    ../../firmware_mpg_common/: AT91SAM3U4.h configuration.h typedefs.h
    ../bsp/: mpgl2-ehdw-02.h
  group _BSP/Source
    ../../firmware_mpg_common/: board_cstartup_iar.c sam3u2-flash.icf
    ../bsp/: mpgl2-ehdw-02.c
  group _CMSIS
    ../../firmware_mpg_common/cmsis/: core_cm3.c core_cm3.h
  group _Drivers/Include
    ../../firmware_mpg_common/drivers/: ant.h ant_api.h antdefines.h antmessage.h buttons.h exceptions.h interrupts.h leds.h messaging.h sam3u_i2c.h sam3u_ssp.h sam3u_uart.h utilities.h
    ../drivers/: captouch.h lcd_bitmaps.h lcd_NHD-C12864LZ.h
  group _Drivers/Source
    ../../firmware_mpg_common/drivers/: ant.c ant_api.c buttons.c exceptions.c interrupts.c leds.c messaging.c sam3u_i2c.c sam3u_ssp.c sam3u_uart.c utilities.c
    ../drivers/: captouch.c lcd_bitmaps.c lcd_NHD-C12864LZ.c
  group _Libraries/bin
    ../libraries/captouch/bin/: libsam3u-32qt-k-8rs-iar.a
  group _Libraries/Include
    ../libraries/captouch/: libqtouch.h
    ../libraries/captouch/include/: touch_api.h touch_qt_config.h
  group Application/Include
    ../../firmware_mpg_common/application/: debug.h music.h user_app.h
    ../application/: main.h mpgl2_board_test.h
  group Application/Source
    ../../firmware_mpg_common/application/: debug.c user_app.c
    ../application/: main.c mpgl2_board_test.c
